# IAR project HPDL1414_clock.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: HPDL1414_clock.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3U STM8S103K3U
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCDiagSuppress: pe188,pa089
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; HARDWARE; APP
  OBJCOPY.OOCOutputFile: HPDL1414_clock.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    APP/: main.c stm8s_it.c stm8s_it.h system_int.c system_int.h
  group HARDWARE
    HARDWARE/: 18b20.c 18b20.h HPDL1414.c HPDL1414.h i2c.c i2c.h uart.c uart.h
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_conf.h stm8s_exti.h stm8s_gpio.h stm8s_i2c.h stm8s_tim4.h stm8s_uart1.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_tim4.c stm8s_uart1.c
